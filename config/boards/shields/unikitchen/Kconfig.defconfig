## config/boards/shields/unikitchen/Kconfig.defconfig
```kconfig
if SHIELD_UNIKITCHEN

config ZMK_KEYBOARD_NAME
    default "kitchen unibody"

config ZMK_USB
    default y

endif
```
